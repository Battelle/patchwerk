## patches/demo_mod/kernel_driver/Kconfig
```kconfig
config BATTELLE
	tristate "Battelle test driver"
	default y
	---help---
	  This is Battelle's test driver for Shmoocon
```
